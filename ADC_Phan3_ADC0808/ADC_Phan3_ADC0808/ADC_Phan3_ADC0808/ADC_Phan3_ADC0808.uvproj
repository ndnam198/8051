# Keil uVision project ADC_Phan3_ADC0808.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ADC_Phan3_ADC0808 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: ru
  group Source Group 1
    ./: main.c
    ../Lib/: Delay.c LCD4.c ADC0808.c
