# Keil uVision project Do_Dong_Ap_ADC0808.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Do_Dong_Ap_ADC0808 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c port.h LCD16x2.c ADC0808.c delay.c
